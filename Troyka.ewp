# IAR project Troyka.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F429xx; USE_STM32F429_DISCO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: C:\STM32\STM32Cube_FW_F4_V1.8.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include; C:\STM32\STM32Cube_FW_F4_V1.8.0\Drivers\STM32F4xx_HAL_Driver\Inc; C:\STM32\STM32Cube_FW_F4_V1.8.0\Drivers\BSP\STM32F429I-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    C:/Users/ARM/Documents/Melkozerova/: defines.h tm_stm32f4_mfrc522.c tm_stm32f4_mfrc522.h tm_stm32f4_spi.c tm_stm32f4_spi.h
    ./: main.c
    C:/STM32/STM32Cube_FW_F4_V1.8.0/Projects/STM32F429I-Discovery/Templates/Src/: stm32f4xx_it.c
